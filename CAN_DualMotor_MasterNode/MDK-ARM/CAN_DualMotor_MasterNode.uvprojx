# Keil uVision project CAN_DualMotor_MasterNode.uvprojx, settings and files
target CAN_DualMotor_MasterNode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CAN_DualMotor_MasterNode +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../BSP;../Control;../Protocol;../Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_can.h stm32f1xx_hal_gpio.h stm32f1xx_hal_i2c.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_hal_tim.h stm32f1xx_hal_uart.h
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: Motor.c Motor.h Encoder.c Encoder.h OLED.c OLED.h Key.c Key.h Bsp_Can.c Bsp_Can.h OLED_Font.h
  group Control
    ../Control/: motor_control.c motor_control.h speed_pi.c speed_pi.h position_control.c position_control.h
  group Protocol
    ../Protocol/: can_protocol.c can_protocol.h
  group Application
    ../Application/: App.c App.h state_machine.c state_machine.h
software components: CMSIS:CORE 4.3.0
